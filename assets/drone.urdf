Commit message: model stuff

File: assets/drone.urdf (robot description, URDF)
Before this commit: robot simple_drone, 9 links, 8 joints
Links:
- link base_link: geometry collision box size=0.3 0.3 0.1; visual mesh filename=./drone.obj scale=1 1 1
